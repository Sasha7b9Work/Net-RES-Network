# Keil uVision project Device.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Device +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB, __cplusplus
  c misc: --cpp
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\CDC;.\src\STM32Cube_F1\Drivers\STM32F1xx_HAL_Driver\Inc;.\src\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;.\src\STM32Cube_F1\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\src\STM32Cube_F1\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F1
    ./src/STM32Cube_F1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_ll_usb.c stm32f1xx_hal_i2c.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd_ex.c
  group src
    ./src/: main.h main.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f103xb.s system_stm32f1xx.c
  group Hardware/CDC
    ./src/STM32Cube_F1/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./src/STM32Cube_F1/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./src/Hardware/CDC/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h CDC.h CDC.cpp
  group Hardware/HAL
    ./src/Hardware/HAL/: stm32f1xx_hal_conf.h stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_it.h HAL.cpp HAL.h
  group Hardware/I2C
    ./src/Hardware/I2C/: i2c.c i2c.h
  group Modules/BME280
    ./src/Modules/BME280/: BME280.h BME280.cpp bme280_defs.h bme280_driver.c bme280_driver.h
  group Modules/HC12
    ./src/Modules/HC12/: HC12.h HC12.cpp
  group Modules/CG-Anem
    ./src/Modules/CG-Anem/: CG-Anem.cpp CG-Anem.h
  group Modules/BH1750
    ./src/Modules/BH1750/: BH1750.cpp BH1750.h
